<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\M4_STEP.ewp</path>
  </project>
  <batchBuild />
</workspace>
